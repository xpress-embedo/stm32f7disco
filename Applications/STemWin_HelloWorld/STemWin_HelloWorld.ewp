# IAR project STemWin_HelloWorld.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F767NI ST STM32F767NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F769xx; USE_STM32F769I_DISCO
  ICCARM.CCIncludePath2: Core\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\Drivers\BSP\STM32F769I-Discovery; ..\..\Drivers\BSP\Components\Common; STemWin\Target; ..\..\Middlewares\ST\STemWin\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STemWin_HelloWorld.hex
  ILINK.IlinkOutputFile: STemWin_HelloWorld.out
  ILINK.IlinkIcfFile: stm32f769xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Applications/EWARM
    ./: startup_stm32f769xx.s
  group Applications/User/Core
    Core/Src/: main.c stm32f7xx_it.c
  group Applications/User/STemWin
    STemWin/App/: BASIC_HelloWorld.c
  group Drivers/BSP/Component
    ../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/BSP/STM32F769I_Discovery
    ../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c stm32f769i_discovery_audio.c stm32f769i_discovery_sdram.c stm32f769i_discovery_ts.c
  group Drivers/CMSIS
    Core/Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2s.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_ll_usb.c
  group Middlewares/STemWin/lib
    ../../Middlewares/ST/STemWin/Lib/: STemWin_CM7_wc32_ARGB.a
  group Middlewares/STemWin/OS
    ../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Middlewares/STemWin/Target
    STemWin/Target/: GUIConf.c LCDConf.c
