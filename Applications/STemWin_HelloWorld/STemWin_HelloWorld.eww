<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STemWin_HelloWorld.ewp</path>
    </project>
    <batchBuild />
</workspace>
